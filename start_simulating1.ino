// C++ code
//
byte bt, i, j, k, p[7]={13,12,11,10,9,8,7};
byte g[16][7]={
    {0,0,0,0,0,0,1},
    {1,0,0,1,1,1,1},
    {0,0,1,0,0,1,0},
    {0,0,0,0,1,1,0},
    {1,0,0,1,1,0,0},
    {0,1,0,0,1,0,0},
    {0,1,0,0,0,0,0},
    {0,0,0,1,1,0,1},
    {0,0,0,0,0,0,0},
    {0,0,0,1,1,0,0},
    {0,0,0,1,0,0,0},
    {1,1,0,0,0,0,0},
    {0,1,1,0,0,0,1},
    {1,0,0,0,0,1,0},
    {0,1,1,0,0,0,0},
    {0,1,1,1,0,0,0}
};
void setup()
{
  for(byte i=0;i<7;i++){
    pinMode(p[i],OUTPUT);
  }
  pinMode(6,INPUT_PULLUP);
}

void loop()
{
  for(byte i=0;i<16;i++)
  {
    for(byte j=0;j<7;j++)
    {

     if( digitalRead(6) == HIGH)
{
     digitalWrite(p[j] ,g[i][j] );
}
else
{
    digitalWrite(p[j] ,HIGH );
}

    }
      delay(1000);
  }
}